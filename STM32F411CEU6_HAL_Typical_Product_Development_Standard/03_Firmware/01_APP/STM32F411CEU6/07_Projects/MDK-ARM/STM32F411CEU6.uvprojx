# Keil uVision project STM32F411CEU6.uvprojx, settings and files
target STM32F411CEU6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411CEU6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ..\..\01_Drivers\STM32F4_HAL_V1_8_5\CMSIS\Device\ST\STM32F4xx\Include;..\..\01_Drivers\STM32F4_HAL_V1_8_5\STM32F4xx_HAL_Driver\Inc;..\..\01_Drivers\STM32F4_HAL_V1_8_5\CMSIS\Include;..\..\00_System\Inc;..\..\02_Core\Inc;..\..\03_BSP\Inc;..\..\06_APP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 00_Startup
    ../../01_Drivers/STM32F4_HAL_V1_8_5/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
    ../../01_Drivers/STM32F4_HAL_V1_8_5/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group 01_Users
    ../../02_Core/Src/: main.c stm32f4xx_it.c
  group 02_Drivers_SYSTEM
    ../../02_Core/Src/: delay.c sys.c uart.c
  group 04_STM32F4xx_HAL_Driver
    ../../01_Drivers/STM32F4_HAL_V1_8_5/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
